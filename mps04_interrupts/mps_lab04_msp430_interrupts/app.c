/*
 * app.c
 *
 *  Created on: 24.10.2026
 *      Author: bboeck
 */


#include <stdbool.h>

#include "app.h"
#include "button.h"
#include "systick.h"
#include "led.h"


#define TICKS_500_MS    50


static unsigned int tick_counter = 0;


/*
 * Initialize the application.
 */
void app_init(void)
{
    led_init();

    button_init();

    systick_init();

    tick_counter = 0;
}


/*
 * Main application loop.
 *
 * The application does not poll hardware registers directly.
 * Instead, it processes events generated by the interrupt-driven
 * hardware modules.
 */
void app_loop(void)
{
    /*
     * Process the periodic 10 ms system tick.
     */
    if (systick_get_event())
    {
        tick_counter++;

        /*
         * Toggle the red LED every 500 ms.
         *
         * 50 * 10 ms = 500 ms
         */
        if (tick_counter >= TICKS_500_MS)
        {
            tick_counter = 0;

            led_red_toggle();
        }
    }


    /*
     * Process a pushbutton event.
     */
    if (button_get_event())
    {
        /*
         * Toggle the green LED once for every
         * detected button event.
         */
        led_green_toggle();
    }
}
