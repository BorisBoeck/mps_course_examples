/*
 * app.c
 *
 *  Created on: 19.11.2026
 *
 *      Author: bboeck
 *
 *      Measure the period of a known external signal using hardware Input Capture.
 *      Uses D9/PA8  TIM1_CH1  as input
 *
 *      CubeMX configuration:
 *      SYSCLK
 *        HSI => PLL => 64MHz
 *
 *      TIM1
 *        Clock Source:       Internal Clock
 *        Channel 1:          Input Capture direct mode
 *
 *        Prescaler:          63
 *        Counter Period:     65535
 *
 *	  	  Input polarity:     Rising Edge
 *		  Input prescaler:    no division
 *		  Input filter:       0
 *
 *	       => 1 count = 1µs
 *
 *	      NVIC Settings:
 *		   → enable TIM1 Capture Compare interrupt
 *
 */

#include "app.h"

#include <stdbool.h>

#include "main.h"
#include "tim.h"


#define CAPTURE_TIMER_HZ    1000000UL


volatile uint16_t capture_delta = 0;
volatile uint32_t measured_frequency_hz = 0;


static uint16_t previous_capture = 0;
static bool first_capture_received = false;


void app_init(void)
{
    capture_delta = 0;
    measured_frequency_hz = 0;

    previous_capture = 0;
    first_capture_received = false;


    /* Start TIM1 Channel 1 Input Capture including capture interrupts.  */
    HAL_TIM_IC_Start_IT(&htim1, TIM_CHANNEL_1);
}


void app_loop(void)
{
    /*
     * Nothing required here.
     *
     * Capture events are handled by the timer hardware
     * and reported through the HAL callback.
     */
}


void HAL_TIM_IC_CaptureCallback(TIM_HandleTypeDef *htim)
{
    uint16_t current_capture;


    /* Check whether the interrupt was generated by TIM1 Channel 1.  */
    if ((htim->Instance == TIM1) && (htim->Channel == HAL_TIM_ACTIVE_CHANNEL_1))
    {
        /* Read captured timer value.     */
        current_capture = (uint16_t)HAL_TIM_ReadCapturedValue(htim, TIM_CHANNEL_1);


        /* The first captured value cannot yet be used to calculate a period.*/
        if (!first_capture_received)
        {
            previous_capture = current_capture;
            first_capture_received = true;

            return;
        }


        /*
         * Calculate the number of timer counts between
         * two rising edges.
         *
         * TIM1 counts from 0 to 65535.
         * Because current_capture and previous_capture
         * are uint16_t, one timer overflow is handled
         * automatically by unsigned arithmetic.
         */
        capture_delta = (uint16_t)(current_capture - previous_capture);


        previous_capture = current_capture;


        /*
         * Convert the measured period into frequency.
         *
         * Timer counter frequency = 1 MHz
         * -> 1 count = 1 us
         */
        if (capture_delta > 0U)
        {
            measured_frequency_hz = CAPTURE_TIMER_HZ / capture_delta;
        }
    }
}
